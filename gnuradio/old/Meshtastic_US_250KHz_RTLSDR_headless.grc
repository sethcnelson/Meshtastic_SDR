options:
  parameters:
    author: Josh Conway (CrankyLinuxUser)
    description: This flow covers all presets at single frequency 906.875MHz , thus only needing a RTL-SDR.
    generate_options: no_gui
    id: Meshtastic_250KHz_all_headless
    output_language: python
    title: Meshtastic_250KHz_all_headless
  states: {}

blocks:
- name: bandpass250k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_250bandwidth/2
    low_cutoff_freq: '-lora_250bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_250bandwidth/50
    win: window.WIN_HAMMING
  states: {}
- name: center_250KHz
  id: variable
  parameters:
    value: '906875000'
  states: {}
- name: cr_44
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr_45
  id: variable
  parameters:
    value: '1'
  states: {}
- name: cr_46
  id: variable
  parameters:
    value: '2'
  states: {}
- name: cr_47
  id: variable
  parameters:
    value: '3'
  states: {}
- name: cr_48
  id: variable
  parameters:
    value: '8'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lora_250bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: payload_length
  id: variable
  parameters:
    value: '237'
  states: {}
- name: preamble_length
  id: variable
  parameters:
    value: '17'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: |-
      Technically the sync-word here for meshtastic is 0x2b
      Trying this leads to no data gathered.
      Using the [0,0] works.
    value: '[0,0]'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: |-
      Set Minoutbuf = 17000
      Frame Sync needs that
    decim: int(samp_rate/(lora_250bandwidth * 4))
    minoutbuf: '17000'
    samp_rate: samp_rate
    taps: bandpass250k
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {state: disabled}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {state: disabled}
- name: lora_sdr_crc_verif_0_1
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {state: disabled}
- name: lora_sdr_crc_verif_0_2
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {state: disabled}
- name: lora_sdr_crc_verif_0_2_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0_1
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0_2
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0_2_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_dewhitening_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_dewhitening_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_dewhitening_0_2
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_dewhitening_0_2_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_fft_demod_0_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_fft_demod_0_1
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_fft_demod_0_2
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_fft_demod_0_2_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      ShortFast
      SF=7, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '7'
    show_log_port: 'True'
    sync_word: sync_word
  states: {state: disabled}
- name: lora_sdr_frame_sync_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      ShortSlow
      SF=8, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '8'
    show_log_port: 'True'
    sync_word: sync_word
  states: {state: disabled}
- name: lora_sdr_frame_sync_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      MediumFast
      SF=9, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '9'
    show_log_port: 'True'
    sync_word: sync_word
  states: {state: disabled}
- name: lora_sdr_frame_sync_0_2
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      MediumSlow
      SF=10,CR=5,BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '10'
    show_log_port: 'True'
    sync_word: sync_word
  states: {state: disabled}
- name: lora_sdr_frame_sync_0_2_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      LongFast
      SF=11,CR=5,BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '11'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_gray_mapping_0_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_gray_mapping_0_1
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_gray_mapping_0_2
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_gray_mapping_0_2_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0_1
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0_2
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0_2_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_45
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {state: disabled}
- name: lora_sdr_header_decoder_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_45
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {state: disabled}
- name: lora_sdr_header_decoder_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_45
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {state: disabled}
- name: lora_sdr_header_decoder_0_2
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_45
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {state: disabled}
- name: lora_sdr_header_decoder_0_2_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_45
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      This flow needs a dependency.
      https://github.com/tapparelj/gr-lora_sdr
    note: 'This flow needs a dependency: https://github.com/tapparelj/gr-lora_sdr'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_250KHz
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq_250KHz
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:20004
    comment: LongFast
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:20003
    comment: MediumSlow
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:20002
    comment: MediumFast
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:20001
    comment: ShortSlow
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_2
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:20000
    comment: ShortFast
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_2_0, '0']
- [lora_sdr_crc_verif_0, '0', zeromq_pub_sink_0_0_2, '0']
- [lora_sdr_crc_verif_0_0, '0', zeromq_pub_sink_0_0_1, '0']
- [lora_sdr_crc_verif_0_1, '0', zeromq_pub_sink_0_0_0, '0']
- [lora_sdr_crc_verif_0_2, '0', zeromq_pub_sink_0_0, '0']
- [lora_sdr_crc_verif_0_2_0, '0', zeromq_pub_sink_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_deinterleaver_0_0, '0', lora_sdr_hamming_dec_0_0, '0']
- [lora_sdr_deinterleaver_0_1, '0', lora_sdr_hamming_dec_0_1, '0']
- [lora_sdr_deinterleaver_0_2, '0', lora_sdr_hamming_dec_0_2, '0']
- [lora_sdr_deinterleaver_0_2_0, '0', lora_sdr_hamming_dec_0_2_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_dewhitening_0_1, '0', lora_sdr_crc_verif_0_1, '0']
- [lora_sdr_dewhitening_0_2, '0', lora_sdr_crc_verif_0_2, '0']
- [lora_sdr_dewhitening_0_2_0, '0', lora_sdr_crc_verif_0_2_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_fft_demod_0_0, '0', lora_sdr_gray_mapping_0_0, '0']
- [lora_sdr_fft_demod_0_1, '0', lora_sdr_gray_mapping_0_1, '0']
- [lora_sdr_fft_demod_0_2, '0', lora_sdr_gray_mapping_0_2, '0']
- [lora_sdr_fft_demod_0_2_0, '0', lora_sdr_gray_mapping_0_2_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0_0, '0', lora_sdr_fft_demod_0_0, '0']
- [lora_sdr_frame_sync_0_1, '0', lora_sdr_fft_demod_0_1, '0']
- [lora_sdr_frame_sync_0_2, '0', lora_sdr_fft_demod_0_2, '0']
- [lora_sdr_frame_sync_0_2_0, '0', lora_sdr_fft_demod_0_2_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_gray_mapping_0_0, '0', lora_sdr_deinterleaver_0_0, '0']
- [lora_sdr_gray_mapping_0_1, '0', lora_sdr_deinterleaver_0_1, '0']
- [lora_sdr_gray_mapping_0_2, '0', lora_sdr_deinterleaver_0_2, '0']
- [lora_sdr_gray_mapping_0_2_0, '0', lora_sdr_deinterleaver_0_2_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_dec_0_0, '0', lora_sdr_header_decoder_0_0, '0']
- [lora_sdr_hamming_dec_0_1, '0', lora_sdr_header_decoder_0_1, '0']
- [lora_sdr_hamming_dec_0_2, '0', lora_sdr_header_decoder_0_2, '0']
- [lora_sdr_hamming_dec_0_2_0, '0', lora_sdr_header_decoder_0_2_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_header_decoder_0_0, '0', lora_sdr_dewhitening_0_0, '0']
- [lora_sdr_header_decoder_0_0, frame_info, lora_sdr_frame_sync_0_0, frame_info]
- [lora_sdr_header_decoder_0_1, '0', lora_sdr_dewhitening_0_1, '0']
- [lora_sdr_header_decoder_0_1, frame_info, lora_sdr_frame_sync_0_1, frame_info]
- [lora_sdr_header_decoder_0_2, '0', lora_sdr_dewhitening_0_2, '0']
- [lora_sdr_header_decoder_0_2, frame_info, lora_sdr_frame_sync_0_2, frame_info]
- [lora_sdr_header_decoder_0_2_0, '0', lora_sdr_dewhitening_0_2_0, '0']
- [lora_sdr_header_decoder_0_2_0, frame_info, lora_sdr_frame_sync_0_2_0, frame_info]
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
